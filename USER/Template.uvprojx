# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\NET\device;..\NET\MQTT;..\NET\onenet;..\HARDWARE\ADC_DMA;..\HARDWARE\BH1750;..\HARDWARE\DHT11;..\HARDWARE\HC_SR04;..\HARDWARE\HC_SR501;..\HARDWARE\MQ;..\HARDWARE\TFT;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_rcc.c
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
  group HARDWARE
    ../HARDWARE/ADC_DMA/: adc_dma.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/HC_SR04/: hc_sr04.c
    ../HARDWARE/HC_SR501/: hc_sr501.c
    ../HARDWARE/MQ/: mq7.c mq2.c
    ../HARDWARE/TFT/: lcd.c gui.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
